options:
  parameters:
    author: Yang
    generate_options: qt_gui
    id: tx
    output_language: python
    title: tx_test
  states: {}

blocks:
- name: BB_gain
  id: variable_qtgui_range
  parameters:
    label: BB_gain
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: IF_gain
  id: variable_qtgui_range
  parameters:
    label: IF_gain
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: tx_gain
    start: '0'
    step: '1'
    stop: '70'
    value: '60'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: '2000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 5e6
    offset: '-0.5'
    phase: '0'
    samp_rate: 50e6
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 50e6
    type: complex
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"bladerf=0,biastee=0" '
    bb_gain0: BB_gain
    freq0: 915e6
    gain0: tx_gain
    if_gain0: IF_gain
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: 50e3
    type: complex
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_sig_source_x_1, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', osmosdr_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
